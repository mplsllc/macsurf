/*
 * macsurf_poison_alloc.c - fixes430 poison allocator.
 *
 * Intercepts malloc/free/calloc/realloc via macros in macsurf_prefix.h.
 * Prepends an 8-byte header (magic + user size) to every allocation.
 * On free: checks magic, memsets the whole block 0xDD, then calls the
 * real free. A use-after-free then crashes at the exact dereference
 * site with PC/LR pointing into 0xDDDDDDDD - unmistakable in MacsBug.
 *
 * The #undefs below restore the real malloc/free for this file so
 * our wrappers can call them without infinite recursion.
 */

/* must come before any stdlib include pulled in by prefix */
#undef malloc
#undef free
#undef calloc
#undef realloc

#include <stdlib.h>
#include <string.h>

#define POISON_MAGIC    0xABCD1234UL
#define POISON_FILL     0xDDu
#define HDR_SZ          8

void *macsurf_debug_malloc(unsigned long n)
{
    unsigned char *base;
    unsigned long *hdr;
    if (n == 0) n = 1;
    base = (unsigned char *)malloc((size_t)(n + HDR_SZ));
    if (!base) return NULL;
    hdr = (unsigned long *)base;
    hdr[0] = POISON_MAGIC;
    hdr[1] = n;
    return base + HDR_SZ;
}

void macsurf_debug_free(void *ptr)
{
    unsigned char *base;
    unsigned long *hdr;
    unsigned long n;
    if (!ptr) return;
    base = (unsigned char *)ptr - HDR_SZ;
    hdr = (unsigned long *)base;
    if (hdr[0] != POISON_MAGIC) {
        /* Not our block (strdup/MSL-internal): just free it. */
        free(ptr);
        return;
    }
    n = hdr[1];
    memset(base, POISON_FILL, (size_t)(n + HDR_SZ));
    free(base);
}

void *macsurf_debug_calloc(unsigned long n, unsigned long sz)
{
    unsigned long total;
    void *p;
    total = n * sz;
    p = macsurf_debug_malloc(total);
    if (p) memset(p, 0, (size_t)total);
    return p;
}

void *macsurf_debug_realloc(void *ptr, unsigned long new_sz)
{
    unsigned char *base;
    unsigned long *hdr;
    unsigned long old_sz;
    void *new_p;
    if (!ptr) return macsurf_debug_malloc(new_sz);
    if (new_sz == 0) { macsurf_debug_free(ptr); return NULL; }
    base = (unsigned char *)ptr - HDR_SZ;
    hdr = (unsigned long *)base;
    if (hdr[0] != POISON_MAGIC) {
        /* Not our block: fall through to real realloc. */
        return realloc(ptr, (size_t)new_sz);
    }
    old_sz = hdr[1];
    new_p = macsurf_debug_malloc(new_sz);
    if (!new_p) return NULL;
    memcpy(new_p, ptr, (size_t)(old_sz < new_sz ? old_sz : new_sz));
    macsurf_debug_free(ptr);
    return new_p;
}
