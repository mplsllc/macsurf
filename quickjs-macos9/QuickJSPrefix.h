#ifndef QUICKJS_PREFIX_H
#define QUICKJS_PREFIX_H

/* Critical Mac OS Compiler Flags */
#define TARGET_CPU_PPC 1
#define TARGET_OS_MAC 1
#define TARGET_API_MAC_CARBON 1
#define TYPE_LONGLONG 1


/* Core Mac Headers (bypassing Carbon.h to avoid Java header conflicts) */
#include <ConditionalMacros.h>
#include <MacTypes.h>
#include <Events.h>
#include <Timer.h>
#include <Quickdraw.h>
#include <Appearance.h>

/* QuickJS Configuration for Mac OS 9 */
#define MAC_OS_9 1
#define CONFIG_BIGNUM 1
#define CONFIG_VERSION "2025-06"

/* Map alloca to built-in */
#include <alloca.h>
#undef alloca
extern void *__alloca(unsigned int);
#define alloca(x) ((void *)__alloca(x))

#endif /* __MWERKS__ */

/* ========================================================
   QuickJS C99 Math & Builtin Polyfills for CodeWarrior 8
   ======================================================== */
#ifdef __MWERKS__
#include <math.h>
#include <time.h>

/* Compiler builtins */
#define __builtin_expect(x, expected_value) (x)

static int __builtin_clz(unsigned int x) {
    int n = 0;
    if (x == 0) return 32;
    while (!(x & 0x80000000)) { n++; x <<= 1; }
    return n;
}

static int __builtin_clzll(unsigned long long x) {
    int n = 0;
    if (x == 0) return 64;
    while (!(x & 0x8000000000000000ULL)) { n++; x <<= 1; }
    return n;
}

static int __builtin_ctz(unsigned int x) {
    int n = 0;
    if (x == 0) return 32;
    while (!(x & 1)) { n++; x >>= 1; }
    return n;
}

/* POSIX Time */
#define gmtime_r(tp, tm) (gmtime(tp) ? (*(tm) = *gmtime(tp), (tm)) : NULL)
#define localtime_r(tp, tm) (localtime(tp) ? (*(tm) = *localtime(tp), (tm)) : NULL)

/* C99 Math Polyfills */
#ifndef trunc
#define trunc(x) ((x) < 0 ? ceil((x)) : floor((x)))
#endif

#ifndef round
#define round(x) ((x) < 0.0 ? ceil((x) - 0.5) : floor((x) + 0.5))
#endif

static double hypot(double x, double y) {
    return sqrt((x)*(x) + (y)*(y));
}

static double cbrt(double x) {
    if (x < 0) return -pow(-x, 1.0/3.0);
    return pow(x, 1.0/3.0);
}

static double log2(double x) {
    return log(x) / 0.693147180559945309417;
}

static double log1p(double x) {
    return log(1.0 + x);
}

static double expm1(double x) {
    return exp(x) - 1.0;
}

#endif /* __MWERKS__ */

/* Fallbacks for Mac OS 9 */
#define NO_TM_GMTOFF 1

#ifndef INFINITY
#define INFINITY (1.0/0.0)
#endif
#ifndef NAN
#define NAN (0.0/0.0)
#endif

/* Fix C89 bools */
#ifndef _Bool
#define _Bool int
#endif
